# Keil uVision project Keyboard.uvprojx, settings and files
target Debug (6120000::V6.12::.\ARMCLANG)
  device: STM32F407IGHx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.14.0-dev22
  cpu: IROM(0x08000000,0x100000) IRAM(0x20000000,0x20000) IRAM2(0x10000000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: Keyboard
  c flags: Optim=2 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: HSE_VALUE=25000000 GLCD_MIRROR_Y = 0, GLCD_SWAP_XY = 0
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group Source
    ./: main.c Keyboard.c stdout_display.c
  group Documentation
    ./: Abstract.txt
target Release (6120000::V6.12::.\ARMCLANG)
  device: STM32F407IGHx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.14.0-dev22
  cpu: as above
  output: Keyboard
  c flags: Optim=4 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: HSE_VALUE=25000000 GLCD_MIRROR_Y = 0, GLCD_SWAP_XY = 0
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
software components: CMSIS:CORE 5.3.0, CMSIS:RTOS2:Keil RTX5 5.5.1, CMSIS:RTOS2:Keil RTX5 5.5.1, Compiler:Event Recorder 1.4.0, Compiler:I/O:STDOUT 1.2.0, Board Support:Graphic LCD 2.0.0, USB:CORE 6.13.6, USB:CORE 6.13.6, USB:Host 6.13.6, USB:Host:HID 6.13.6, CMSIS Driver:USB Host:Full-speed 2.21, CMSIS Driver:USB Host:High-speed 2.22, Device:STM32Cube Framework:Classic 1.7.6, Device:STM32Cube HAL:ADC 1.7.6, Device:STM32Cube HAL:Common 1.7.6, Device:STM32Cube HAL:Cortex 1.7.6, Device:STM32Cube HAL:DMA 1.7.6, Device:STM32Cube HAL:GPIO 1.7.6, Device:STM32Cube HAL:PWR 1.7.6, Device:STM32Cube HAL:RCC 1.7.6, Device:STM32Cube HAL:SRAM 1.7.6, Device:Startup 2.6.3
